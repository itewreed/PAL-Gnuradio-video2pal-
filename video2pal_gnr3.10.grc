options:
  parameters:
    generate_options: qt_gui
    id: pal_transmit_2022_v2
    output_language: python
    title: Pal Transmit via Gnuradio
  states: {}

blocks:
- name: chroma_carrier
  id: variable
  parameters:
    value: '4433618.75'
  states: {}
- name: level_black
  id: variable
  parameters:
    value: '0.339'
  states: {}
- name: level_blank
  id: variable
  parameters:
    value: '0.285'
  states: {}
- name: lines_half_frame
  id: variable
  parameters:
    value: '305'
  states: {}
- name: lines_visual
  id: variable
  parameters:
    value: '576'
  states: {}
- name: samp_burst
  id: variable
  parameters:
    value: int(2.25/64*samp_line)
  states: {}
- name: samp_burst_delay
  id: variable
  parameters:
    value: int(0.9/64*samp_line)
  states: {}
- name: samp_h_sync
  id: variable
  parameters:
    value: int(4.7/64*samp_line)
  states: {}
- name: samp_line
  id: variable
  parameters:
    value: int((64e-6)*samp_rate)
  states: {}
- name: samp_long_low
  id: variable
  parameters:
    value: int(27.3/32*samp_half_line)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_visual/(52e-6)
  states: {}
- name: samp_short_low
  id: variable
  parameters:
    value: int(2.35/32*samp_half_line)
  states: {}
- name: samp_visual
  id: variable
  parameters:
    value: '702'
  states: {}
- name: samp_visual_delay
  id: variable
  parameters:
    value: int(2.5/64*samp_line)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_10
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_11
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_12
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_13
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_14
  id: analog_const_source_x
  parameters:
    const: (-1+1j)/sqrt(2)
    type: complex
  states: {}
- name: analog_const_source_x_15
  id: analog_const_source_x
  parameters:
    const: (-1-1j)/sqrt(2)
    type: complex
  states: {}
- name: analog_const_source_x_16
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_17
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_18
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_const_source_x_19
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_3
  id: analog_const_source_x
  parameters:
    comment: 0 V (Black burst)
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_3_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_4
  id: analog_const_source_x
  parameters:
    comment: 0.285 V (H-Sync)
    const: level_blank
    type: complex
  states: {}
- name: analog_const_source_x_4_0
  id: analog_const_source_x
  parameters:
    const: level_blank
    type: complex
  states: {}
- name: analog_const_source_x_5
  id: analog_const_source_x
  parameters:
    comment: 0.285 V
    const: level_blank
    type: complex
  states: {}
- name: analog_const_source_x_5_0
  id: analog_const_source_x
  parameters:
    const: level_blank
    type: complex
  states: {}
- name: analog_const_source_x_6
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_6_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_7
  id: analog_const_source_x
  parameters:
    const: level_blank
    type: complex
  states: {}
- name: analog_const_source_x_7_0
  id: analog_const_source_x
  parameters:
    const: level_blank
    type: complex
  states: {}
- name: analog_const_source_x_8
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_const_source_x_9
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.68'
    freq: chroma_carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      0.339 V (Active Area where 0.3 V
      full black and 1 V full white)
    const: level_black
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: level_black
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters:
    comment: |-
      Phase alternation of every even line
      (Thus PAL)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: YUV.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: lines_half_frame*samp_visual
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters:
    vlen: lines_half_frame*samp_visual
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.00390625/2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: samp_burst
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (8, int(lines_visual/2), 9)
    num_inputs: '3'
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (9, int(lines_visual/2), 8)
    num_inputs: '3'
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_stream_mux_10
  id: blocks_stream_mux
  parameters:
    lengths: (8, lines_half_frame, 7, lines_half_frame)
    num_inputs: '4'
    type: complex
    vlen: samp_burst
  states: {}
- name: blocks_stream_mux_2
  id: blocks_stream_mux
  parameters:
    comment: Adding H-Sync
    lengths: (samp_h_sync, samp_burst_delay+samp_burst+samp_visual_delay, samp_visual, samp_line-(samp_h_sync+samp_burst_delay+samp_burst+samp_visual_delay+samp_visual))
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_stream_mux_2_0
  id: blocks_stream_mux
  parameters:
    comment: Adding H-Sync
    lengths: (samp_h_sync, samp_burst_delay+samp_burst+samp_visual_delay, samp_visual, samp_line-(samp_h_sync+samp_burst_delay+samp_burst+samp_visual_delay+samp_visual))
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_stream_mux_3
  id: blocks_stream_mux
  parameters:
    comment: |-
      Combine half-frames and add V-Sync
      6 short
      5 long
      5 short
      305 lines
      5 short
      5 long
      4 short
      305 lines
    lengths: (6, 5, 5, 2*305, 5, 5, 4, 2*305)
    num_inputs: '8'
    type: complex
    vlen: int(samp_line/2)
  states: {}
- name: blocks_stream_mux_4
  id: blocks_stream_mux
  parameters:
    comment: |-
      single short
      sync pulses
    lengths: (samp_short_low, samp_half_line-samp_short_low)
    type: complex
  states: {}
- name: blocks_stream_mux_5
  id: blocks_stream_mux
  parameters:
    comment: |-
      single long
      sync pulse
    lengths: (samp_long_low, samp_half_line-samp_long_low)
    type: complex
  states: {}
- name: blocks_stream_mux_6
  id: blocks_stream_mux
  parameters:
    comment: |-
      Adding blank lines which
      represent vbi and V-Sync in Y (luma),
      but not used in chroma
    lengths: (8, lines_half_frame, 7, lines_half_frame)
    num_inputs: '4'
    type: complex
    vlen: samp_visual
  states: {}
- name: blocks_stream_mux_7
  id: blocks_stream_mux
  parameters:
    lengths: (samp_visual, samp_visual)
    type: complex
  states: {}
- name: blocks_stream_mux_8
  id: blocks_stream_mux
  parameters:
    lengths: (samp_h_sync+samp_burst_delay, samp_burst, samp_visual_delay, samp_visual, samp_line-(samp_h_sync+samp_burst_delay+samp_burst+samp_visual_delay+samp_visual))
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_stream_mux_9
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: complex
    vlen: samp_burst
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    comment: |-
      split even and
      odd triples
      Interleave:
      out0 = odd
      out1 = even
    type: float
    vlen: samp_visual*lines_visual*3
  states: {}
- name: blocks_stream_to_streams_1
  id: blocks_stream_to_streams
  parameters:
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_stream_to_streams_1_0
  id: blocks_stream_to_streams
  parameters:
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_stream_to_streams_2
  id: blocks_stream_to_streams
  parameters:
    num_streams: '3'
    type: float
    vlen: lines_half_frame*samp_visual
  states: {}
- name: blocks_stream_to_streams_2_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: '3'
    type: float
    vlen: lines_half_frame*samp_visual
  states: {}
- name: blocks_stream_to_streams_3
  id: blocks_stream_to_streams
  parameters:
    comment: |-
      Interleave
      out0 = every odd line
      out1 = every even line
      of odd and even frames
    type: complex
    vlen: samp_visual
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      bundle pixels
      to YUV triples
      (3*702*576)
      3* because Y-U-V
      1 Vector = 1 set of YUV Frame
    num_items: 3*samp_visual*lines_visual
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_visual
    type: float
  states: {}
- name: blocks_stream_to_vector_10
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_line
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      bundle lines
      to frames
      305 vectors of 702 samples each
      are packed to one new vector
      (702*305)
    num_items: lines_half_frame
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_stream_to_vector_2_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      bundle lines
      to frames
      305 vectors of 702 samples each
      are packed to one new vector
      (702*305)
    num_items: lines_half_frame
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_stream_to_vector_3
  id: blocks_stream_to_vector
  parameters:
    num_items: int(samp_line/2)
    type: complex
  states: {}
- name: blocks_stream_to_vector_4
  id: blocks_stream_to_vector
  parameters:
    num_items: int(samp_line/2)
    type: complex
  states: {}
- name: blocks_stream_to_vector_5
  id: blocks_stream_to_vector
  parameters:
    num_items: int(samp_line/2)
    type: complex
  states: {}
- name: blocks_stream_to_vector_5_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(samp_line/2)
    type: complex
  states: {}
- name: blocks_stream_to_vector_6
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Stream made to
      vector of one (active) line
      length (e.g 702 samples)
    num_items: samp_visual
    type: complex
  states: {}
- name: blocks_stream_to_vector_6_0
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_visual
    type: complex
  states: {}
- name: blocks_stream_to_vector_7
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_visual
    type: complex
  states: {}
- name: blocks_stream_to_vector_7_0
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_visual
    type: complex
  states: {}
- name: blocks_stream_to_vector_8
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_burst
    type: complex
  states: {}
- name: blocks_stream_to_vector_8_0
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_burst
    type: complex
  states: {}
- name: blocks_stream_to_vector_9
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_burst
    type: complex
  states: {}
- name: blocks_stream_to_vector_9_0
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_burst
    type: complex
  states: {}
- name: blocks_stream_to_vector_9_1
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_burst
    type: complex
  states: {}
- name: blocks_stream_to_vector_9_2
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_burst
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    comment: |-
      seperate YUV
      triples to lines
      (3*576)
      Vector length=702
      Produces 1728 Samples
      whereas each sample consists
      of 702 subsamples
    num_items: 3*lines_visual
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 3*lines_visual
    type: float
    vlen: samp_visual
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: lines_half_frame*samp_visual
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: lines_half_frame*samp_visual
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: lines_half_frame*samp_visual
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: int(samp_line/2)
    type: complex
  states: {}
- name: blocks_vector_to_stream_3
  id: blocks_vector_to_stream
  parameters:
    comment: |-
      Vector is one half frame
      made to stream.
    num_items: lines_half_frame*samp_visual
    type: complex
  states: {}
- name: blocks_vector_to_stream_3_0
  id: blocks_vector_to_stream
  parameters:
    num_items: lines_half_frame*samp_visual
    type: complex
  states: {}
- name: blocks_vector_to_stream_4
  id: blocks_vector_to_stream
  parameters:
    num_items: samp_visual
    type: complex
  states: {}
- name: blocks_vector_to_stream_4_0
  id: blocks_vector_to_stream
  parameters:
    num_items: samp_visual
    type: complex
  states: {}
- name: blocks_vector_to_stream_5
  id: blocks_vector_to_stream
  parameters:
    num_items: samp_burst
    type: complex
  states: {}
- name: blocks_vector_to_stream_6
  id: blocks_vector_to_stream
  parameters:
    num_items: samp_line
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '24'
    freq0: 655.25e6
    gain0: '14'
    if_gain0: '48'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: samp_half_line
  id: parameter
  parameters:
    label: Samples per line
    type: intx
    value: '432'
  states: {}
- name: video_sdl_sink_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Check Half-frame,
      only active samples
    display_height: lines_half_frame
    display_width: samp_visual
    fps: '0'
    height: lines_half_frame
    type: byte
    width: samp_visual
  states: {state: disabled}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Check Half-frame,
      all samples
    display_height: lines_half_frame
    display_width: samp_line
    fps: '0'
    height: lines_half_frame
    type: byte
    width: samp_line
  states: {state: disabled}
- name: video_sdl_sink_0_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Check full frame,
      all samples
    display_height: lines_half_frame*2+15
    display_width: samp_line
    fps: '0'
    height: lines_half_frame*2+15
    type: byte
    width: samp_line
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: nullsource_samp_visual
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: yuv_odd_frames
  states: {}
- name: virtual_sink_10
  id: virtual_sink
  parameters:
    comment: for direct composite (CVBS) output
    stream_id: y_baseband
  states: {}
- name: virtual_sink_11
  id: virtual_sink
  parameters:
    stream_id: c_carrier
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: yuv_even_frames
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: y_odd_frames
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: y_even_frames
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: uv_odd_frames
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: uv_even_frames
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: short_sync_p
  states: {}
- name: virtual_sink_8
  id: virtual_sink
  parameters:
    stream_id: long_sync_p
  states: {}
- name: virtual_sink_9
  id: virtual_sink
  parameters:
    comment: |-
      For broadcast on HF frequencies
      (as amplitude is broadcasted inverted,
      for better SNR)
    stream_id: y_baseband_inverted
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: nullsource_samp_visual
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: nullsource_samp_visual
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: nullsource_samp_visual
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: nullsource_samp_visual
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: yuv_odd_frames
  states: {}
- name: virtual_source_10
  id: virtual_source
  parameters:
    stream_id: y_baseband_inverted
  states: {}
- name: virtual_source_11
  id: virtual_source
  parameters:
    stream_id: c_carrier
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: yuv_even_frames
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: y_odd_frames
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: y_even_frames
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: uv_odd_frames
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: uv_even_frames
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: short_sync_p
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: long_sync_p
  states: {}
- name: virtual_source_9
  id: virtual_source
  parameters:
    stream_id: y_baseband_inverted
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_to_vector_1, '0']
- [analog_const_source_x_1, '0', blocks_float_to_complex_1, '1']
- [analog_const_source_x_10, '0', blocks_stream_to_vector_7, '0']
- [analog_const_source_x_11, '0', blocks_stream_mux_8, '4']
- [analog_const_source_x_12, '0', blocks_stream_mux_8, '2']
- [analog_const_source_x_13, '0', blocks_stream_mux_8, '0']
- [analog_const_source_x_14, '0', blocks_stream_to_vector_8_0, '0']
- [analog_const_source_x_15, '0', blocks_stream_to_vector_8, '0']
- [analog_const_source_x_16, '0', blocks_stream_to_vector_9, '0']
- [analog_const_source_x_17, '0', blocks_stream_to_vector_9_1, '0']
- [analog_const_source_x_18, '0', blocks_stream_to_vector_9_0, '0']
- [analog_const_source_x_19, '0', blocks_stream_to_vector_9_2, '0']
- [analog_const_source_x_2, '0', blocks_float_to_complex_2, '1']
- [analog_const_source_x_3, '0', blocks_stream_mux_2, '0']
- [analog_const_source_x_3_0, '0', blocks_stream_mux_2_0, '0']
- [analog_const_source_x_4, '0', blocks_stream_mux_2, '1']
- [analog_const_source_x_4_0, '0', blocks_stream_mux_2_0, '1']
- [analog_const_source_x_5, '0', blocks_stream_mux_2, '3']
- [analog_const_source_x_5_0, '0', blocks_stream_mux_2_0, '3']
- [analog_const_source_x_6, '0', blocks_stream_mux_4, '0']
- [analog_const_source_x_6_0, '0', blocks_stream_mux_5, '0']
- [analog_const_source_x_7, '0', blocks_stream_mux_4, '1']
- [analog_const_source_x_7_0, '0', blocks_stream_mux_5, '1']
- [analog_const_source_x_8, '0', blocks_sub_xx_0, '0']
- [analog_const_source_x_9, '0', blocks_stream_to_vector_7_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_stream_mux_2, '2']
- [blocks_add_const_vxx_0_0, '0', blocks_stream_mux_2_0, '2']
- [blocks_add_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_10, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_stream_mux_7, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_char_0_0, '0', video_sdl_sink_0_0, '0']
- [blocks_float_to_char_0_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_float_to_char_0_0, '0', video_sdl_sink_0_0_0_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_5, '0']
- [blocks_float_to_complex_0_0, '0', virtual_sink_6, '0']
- [blocks_float_to_complex_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_complex_2, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_vector_to_stream_5, '0']
- [blocks_multiply_xx_1, '0', virtual_sink_11, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_stream_mux_1, '0', blocks_stream_to_vector_2_0, '0']
- [blocks_stream_mux_10, '0', blocks_multiply_xx_0, '1']
- [blocks_stream_mux_2, '0', blocks_stream_to_vector_3, '0']
- [blocks_stream_mux_2_0, '0', blocks_stream_to_vector_4, '0']
- [blocks_stream_mux_3, '0', blocks_vector_to_stream_2, '0']
- [blocks_stream_mux_4, '0', blocks_stream_to_vector_5, '0']
- [blocks_stream_mux_5, '0', blocks_stream_to_vector_5_0, '0']
- [blocks_stream_mux_6, '0', blocks_stream_to_streams_3, '0']
- [blocks_stream_mux_7, '0', blocks_stream_mux_8, '3']
- [blocks_stream_mux_8, '0', blocks_multiply_xx_1, '0']
- [blocks_stream_mux_9, '0', blocks_multiply_xx_0, '0']
- [blocks_stream_to_streams_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_vector_to_stream_0_0, '0']
- [blocks_stream_to_streams_1, '0', blocks_stream_mux_0, '1']
- [blocks_stream_to_streams_1, '1', blocks_null_sink_0, '0']
- [blocks_stream_to_streams_1_0, '0', blocks_null_sink_0_1, '0']
- [blocks_stream_to_streams_1_0, '1', blocks_stream_mux_1, '1']
- [blocks_stream_to_streams_2, '0', blocks_vector_to_stream_1, '0']
- [blocks_stream_to_streams_2, '1', blocks_float_to_complex_0, '0']
- [blocks_stream_to_streams_2, '2', blocks_float_to_complex_0, '1']
- [blocks_stream_to_streams_2_0, '0', blocks_vector_to_stream_1_0, '0']
- [blocks_stream_to_streams_2_0, '1', blocks_float_to_complex_0_0, '0']
- [blocks_stream_to_streams_2_0, '2', blocks_float_to_complex_0_0, '1']
- [blocks_stream_to_streams_3, '0', blocks_vector_to_stream_4, '0']
- [blocks_stream_to_streams_3, '1', blocks_vector_to_stream_4_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_stream_to_vector_1, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_10, '0', blocks_vector_to_stream_6, '0']
- [blocks_stream_to_vector_2, '0', virtual_sink_1, '0']
- [blocks_stream_to_vector_2_0, '0', virtual_sink_2, '0']
- [blocks_stream_to_vector_3, '0', blocks_stream_mux_3, '3']
- [blocks_stream_to_vector_4, '0', blocks_stream_mux_3, '7']
- [blocks_stream_to_vector_5, '0', virtual_sink_7, '0']
- [blocks_stream_to_vector_5_0, '0', virtual_sink_8, '0']
- [blocks_stream_to_vector_6, '0', blocks_stream_mux_6, '1']
- [blocks_stream_to_vector_6_0, '0', blocks_stream_mux_6, '3']
- [blocks_stream_to_vector_7, '0', blocks_stream_mux_6, '2']
- [blocks_stream_to_vector_7_0, '0', blocks_stream_mux_6, '0']
- [blocks_stream_to_vector_8, '0', blocks_stream_mux_9, '1']
- [blocks_stream_to_vector_8_0, '0', blocks_stream_mux_9, '0']
- [blocks_stream_to_vector_9, '0', blocks_stream_mux_10, '0']
- [blocks_stream_to_vector_9_0, '0', blocks_stream_mux_10, '1']
- [blocks_stream_to_vector_9_1, '0', blocks_stream_mux_10, '2']
- [blocks_stream_to_vector_9_2, '0', blocks_stream_mux_10, '3']
- [blocks_sub_xx_0, '0', virtual_sink_9, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_streams_1, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_stream_to_streams_1_0, '0']
- [blocks_vector_to_stream_1, '0', virtual_sink_3, '0']
- [blocks_vector_to_stream_1_0, '0', virtual_sink_4, '0']
- [blocks_vector_to_stream_2, '0', blocks_sub_xx_0, '1']
- [blocks_vector_to_stream_2, '0', virtual_sink_10, '0']
- [blocks_vector_to_stream_3, '0', blocks_stream_to_vector_6, '0']
- [blocks_vector_to_stream_3_0, '0', blocks_stream_to_vector_6_0, '0']
- [blocks_vector_to_stream_4, '0', blocks_stream_mux_7, '0']
- [blocks_vector_to_stream_4_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_vector_to_stream_5, '0', blocks_stream_mux_8, '1']
- [blocks_vector_to_stream_6, '0', osmosdr_sink_0, '0']
- [virtual_source_0, '0', blocks_stream_mux_0, '0']
- [virtual_source_0_0, '0', blocks_stream_mux_0, '2']
- [virtual_source_0_1, '0', blocks_stream_mux_1, '2']
- [virtual_source_0_2, '0', blocks_stream_mux_1, '0']
- [virtual_source_1, '0', blocks_stream_to_streams_2, '0']
- [virtual_source_10, '0', blocks_null_sink_2, '0']
- [virtual_source_11, '0', blocks_add_xx_0, '1']
- [virtual_source_2, '0', blocks_stream_to_streams_2_0, '0']
- [virtual_source_3, '0', blocks_float_to_complex_1, '0']
- [virtual_source_4, '0', blocks_float_to_complex_2, '0']
- [virtual_source_5, '0', blocks_vector_to_stream_3, '0']
- [virtual_source_6, '0', blocks_vector_to_stream_3_0, '0']
- [virtual_source_7, '0', blocks_stream_mux_3, '0']
- [virtual_source_7, '0', blocks_stream_mux_3, '2']
- [virtual_source_7, '0', blocks_stream_mux_3, '4']
- [virtual_source_7, '0', blocks_stream_mux_3, '6']
- [virtual_source_8, '0', blocks_stream_mux_3, '1']
- [virtual_source_8, '0', blocks_stream_mux_3, '5']
- [virtual_source_9, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
